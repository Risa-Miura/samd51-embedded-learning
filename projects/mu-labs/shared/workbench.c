/* Original SAMD51 adaptation. Source references and deviations are in docs.
 * Register API: Microchip SAMD51_DFP 3.10.283; CMSIS 6.4.0.
 */
#include "workbench.h"
#include <stddef.h>
volatile uint32_t g_fault_stage;
volatile uint32_t g_dma_blocks, g_dma_errors, g_adc_overruns, g_buffer_ready;
volatile uint16_t g_samples[SAMPLE_COUNT] __attribute__((aligned(16)));
dmac_descriptor_registers_t g_descriptor __attribute__((aligned(16)));
volatile dmac_descriptor_registers_t g_writeback __attribute__((aligned(16)));
_Static_assert(sizeof(dmac_descriptor_registers_t)==16, "DMAC descriptor size");
_Static_assert(offsetof(dmac_descriptor_registers_t,DMAC_DSTADDR)==8, "Descriptor layout");
_Static_assert(TC3_GCLK_ID==26 && ADC1_GCLK_ID==41 && TCC0_GCLK_ID==25, "Clock IDs");
_Static_assert(ADC1_DMAC_ID_RESRDY==70, "ADC1 DMA request ID");
_Static_assert(EVENT_ID_GEN_DMAC_CH_0==34 && EVENT_ID_USER_ADC1_START==57, "Event IDs");
_Static_assert(PIN_PB01==33 && PIN_PC04==68 && PIN_PB04==36, "Board pad identities");
_Static_assert(MUX_PC04A_EIC_EXTINT4==0 && MUX_PB04B_ADC1_AIN6==1, "Input mux selections");
_Static_assert(MUX_PA16M_GCLK_IO2==12 && MUX_PC18F_TCC0_WO2==5 && MUX_PA18E_TC3_WO0==4, "Output mux selections");

void wait32(volatile const uint32_t *reg,uint32_t mask,bool set,uint32_t stage)
{
    uint32_t left=0x10000000u;
    while (((*reg & mask)==mask)!=set) {
        if (--left==0) { g_fault_stage=stage; for (;;) { __NOP(); } }
    }
}

static void wait8(volatile const uint8_t *reg,uint8_t mask,bool set,uint32_t stage)
{
    uint32_t left=0x10000000u;
    while (((*reg & mask)==mask)!=set) {
        if (--left==0) { g_fault_stage=stage; for (;;) { __NOP(); } }
    }
}

static void wait16(volatile const uint16_t *reg,uint16_t mask,bool set,uint32_t stage)
{
    uint32_t left=0x10000000u;
    while (((*reg & mask)==mask)!=set) {
        if (--left==0) { g_fault_stage=stage; for (;;) { __NOP(); } }
    }
}

void pin_mux(unsigned group,unsigned pin,unsigned function)
{
    /* Preserve the PMUX nibble belonging to the adjacent pin. */
    unsigned shift=(pin & 1u)*4u;
    uint8_t old=PORT_REGS->GROUP[group].PORT_PMUX[pin/2];
    PORT_REGS->GROUP[group].PORT_PMUX[pin/2]=(old & ~(0xfu<<shift)) | (function<<shift);
    PORT_REGS->GROUP[group].PORT_PINCFG[pin]=PORT_PINCFG_PMUXEN(1);
}

void board_init(void)
{
    MCLK_REGS->MCLK_APBBMASK |= MCLK_APBBMASK_PORT(1);
    PORT_REGS->GROUP[1].PORT_PINCFG[1]=0;
    PORT_REGS->GROUP[1].PORT_PINCFG[0]=0;
    PORT_REGS->GROUP[1].PORT_OUTCLR=LED_MASK | MIRROR_MASK;
    PORT_REGS->GROUP[1].PORT_DIRSET=LED_MASK | MIRROR_MASK;
    PORT_REGS->GROUP[0].PORT_PINCFG[19]=0;
    PORT_REGS->GROUP[0].PORT_OUTCLR=MARKER_MASK;
    PORT_REGS->GROUP[0].PORT_DIRSET=MARKER_MASK;
    PORT_REGS->GROUP[2].PORT_DIRCLR=BUTTON_MASK;
    PORT_REGS->GROUP[2].PORT_OUTSET=BUTTON_MASK; /* Pull direction = up. */
    PORT_REGS->GROUP[2].PORT_PINCFG[4]=PORT_PINCFG_INEN(1) | PORT_PINCFG_PULLEN(1);
    PORT_REGS->GROUP[2].PORT_CTRL |= BUTTON_MASK; /* Continuous sampling of input byte. */
}

static void clock_channel(unsigned channel,unsigned generator)
{
    /* Refuse a bootloader/write-locked channel rather than silently misconfigure it. */
    if (GCLK_REGS->GCLK_PCHCTRL[channel] & GCLK_PCHCTRL_WRTLOCK(1)) {
        g_fault_stage=100+channel; for (;;) { __NOP(); }
    }
    GCLK_REGS->GCLK_PCHCTRL[channel]=0;
    wait32(&GCLK_REGS->GCLK_PCHCTRL[channel],GCLK_PCHCTRL_CHEN(1),false,200+channel);
    GCLK_REGS->GCLK_PCHCTRL[channel]=GCLK_PCHCTRL_GEN(generator)|GCLK_PCHCTRL_CHEN(1);
    wait32(&GCLK_REGS->GCLK_PCHCTRL[channel],GCLK_PCHCTRL_CHEN(1),true,300+channel);
}

void clock_init(void)
{
    MCLK_REGS->MCLK_APBAMASK |= MCLK_APBAMASK_GCLK(1)|MCLK_APBAMASK_OSCCTRL(1)|MCLK_APBAMASK_OSC32KCTRL(1);
    /* DS60001507N: DFLL open loop is specified for LDO regulator mode only.
     * Do not switch a live regulator configuration as a hidden side effect.
     */
    if (SUPC_REGS->SUPC_VREG & SUPC_VREG_SEL(1)) {
        g_fault_stage=11; for (;;) { __NOP(); }
    }
    /* Conservative volatile wait-state setting, not a fuse write. */
    NVMCTRL_REGS->NVMCTRL_CTRLA=(NVMCTRL_REGS->NVMCTRL_CTRLA & ~NVMCTRL_CTRLA_RWS_Msk)|NVMCTRL_CTRLA_RWS(5);
    OSCCTRL_REGS->OSCCTRL_DFLLCTRLA=OSCCTRL_DFLLCTRLA_ENABLE(1); /* ONDEMAND=0. */
    wait8(&OSCCTRL_REGS->OSCCTRL_DFLLSYNC,OSCCTRL_DFLLSYNC_ENABLE(1),false,1);
    OSCCTRL_REGS->OSCCTRL_DFLLCTRLB=0; /* Open loop, no USB clock recovery. */
    wait8(&OSCCTRL_REGS->OSCCTRL_DFLLSYNC,OSCCTRL_DFLLSYNC_DFLLCTRLB(1),false,2);
    wait32(&OSCCTRL_REGS->OSCCTRL_STATUS,OSCCTRL_STATUS_DFLLRDY(1),true,3);
    GCLK_REGS->GCLK_GENCTRL[0]=GCLK_GENCTRL_SRC_DFLL|GCLK_GENCTRL_GENEN(1)|GCLK_GENCTRL_DIV(1);
    wait32(&GCLK_REGS->GCLK_SYNCBUSY,GCLK_SYNCBUSY_GENCTRL_GCLK0,false,4);
    MCLK_REGS->MCLK_CPUDIV=MCLK_CPUDIV_DIV_DIV1;
#if LAB_CLOSED_LOOP
    /* Grand Central rev B schematic: X4=32.768 kHz on PA00/PA01. */
    OSC32KCTRL_REGS->OSC32KCTRL_XOSC32K=OSC32KCTRL_XOSC32K_STARTUP(6)
        |OSC32KCTRL_XOSC32K_XTALEN(1)|OSC32KCTRL_XOSC32K_EN32K(1)|OSC32KCTRL_XOSC32K_ENABLE(1);
    wait32(&OSC32KCTRL_REGS->OSC32KCTRL_STATUS,OSC32KCTRL_STATUS_XOSC32KRDY(1),true,5);
    GCLK_REGS->GCLK_GENCTRL[3]=GCLK_GENCTRL_SRC_XOSC32K|GCLK_GENCTRL_GENEN(1)|GCLK_GENCTRL_DIV(1);
    wait32(&GCLK_REGS->GCLK_SYNCBUSY,GCLK_SYNCBUSY_GENCTRL_GCLK3,false,6);
    clock_channel(OSCCTRL_GCLK_ID_DFLL48,3);
    OSCCTRL_REGS->OSCCTRL_DFLLMUL=OSCCTRL_DFLLMUL_MUL(1465)|OSCCTRL_DFLLMUL_CSTEP(5)|OSCCTRL_DFLLMUL_FSTEP(1);
    wait8(&OSCCTRL_REGS->OSCCTRL_DFLLSYNC,OSCCTRL_DFLLSYNC_DFLLMUL(1),false,7);
    OSCCTRL_REGS->OSCCTRL_DFLLCTRLB=OSCCTRL_DFLLCTRLB_MODE(1);
    wait8(&OSCCTRL_REGS->OSCCTRL_DFLLSYNC,OSCCTRL_DFLLSYNC_DFLLCTRLB(1),false,8);
    wait32(&OSCCTRL_REGS->OSCCTRL_STATUS,OSCCTRL_STATUS_DFLLLCKC(1)|OSCCTRL_STATUS_DFLLLCKF(1),true,9);
#endif
    /* D37=PA16/M=GCLK_IO2. Divide source by 48 for a usable AD2 clock probe. */
    GCLK_REGS->GCLK_GENCTRL[2]=GCLK_GENCTRL_SRC_DFLL|GCLK_GENCTRL_DIV(48)
        |GCLK_GENCTRL_GENEN(1)|GCLK_GENCTRL_OE(1)|GCLK_GENCTRL_IDC(1);
    wait32(&GCLK_REGS->GCLK_SYNCBUSY,GCLK_SYNCBUSY_GENCTRL_GCLK2,false,10);
    pin_mux(0,16,12);
    PORT_REGS->GROUP[0].PORT_DIRSET=1u<<16;
}

void tc3_init(void)
{
    MCLK_REGS->MCLK_APBBMASK |= MCLK_APBBMASK_TC3(1);
    clock_channel(TC3_GCLK_ID,0);
    TC3_REGS->COUNT16.TC_CTRLA=0;
    wait32(&TC3_REGS->COUNT16.TC_SYNCBUSY,TC_SYNCBUSY_ENABLE(1),false,20);
    TC3_REGS->COUNT16.TC_CTRLA=TC_CTRLA_SWRST(1);
    wait32(&TC3_REGS->COUNT16.TC_SYNCBUSY,TC_SYNCBUSY_SWRST(1),false,21);
    wait32(&TC3_REGS->COUNT16.TC_CTRLA,TC_CTRLA_SWRST(1),false,21);
    TC3_REGS->COUNT16.TC_CTRLA=TC_CTRLA_MODE_COUNT16|TC_CTRLA_PRESCALER_DIV16;
    TC3_REGS->COUNT16.TC_WAVE=TC_WAVE_WAVEGEN_MFRQ;
    TC3_REGS->COUNT16.TC_CC[0]=2999; /* (48 MHz/16)/1000 - 1. */
    wait32(&TC3_REGS->COUNT16.TC_SYNCBUSY,TC_SYNCBUSY_CC0(1),false,22);
    /* D35=PA18/E=TC3/WO0: 500 Hz hardware reference, two 1 ms intervals/cycle. */
    pin_mux(0,18,4);
    PORT_REGS->GROUP[0].PORT_DIRSET=1u<<18;
    TC3_REGS->COUNT16.TC_INTFLAG=TC_INTFLAG_MC0(1)|TC_INTFLAG_OVF(1);
    TC3_REGS->COUNT16.TC_INTENSET=TC_INTENSET_MC0(1);
    NVIC_ClearPendingIRQ(TC3_IRQn); NVIC_SetPriority(TC3_IRQn,2); NVIC_EnableIRQ(TC3_IRQn);
    TC3_REGS->COUNT16.TC_CTRLA |= TC_CTRLA_ENABLE(1);
    wait32(&TC3_REGS->COUNT16.TC_SYNCBUSY,TC_SYNCBUSY_ENABLE(1),false,23);
}

void rtc_set_period(uint32_t ticks)
{
    RTC_REGS->MODE0.RTC_CTRLA &= ~RTC_MODE0_CTRLA_ENABLE(1);
    wait32(&RTC_REGS->MODE0.RTC_SYNCBUSY,RTC_MODE0_SYNCBUSY_ENABLE(1),false,30);
    RTC_REGS->MODE0.RTC_COUNT=0;
    wait32(&RTC_REGS->MODE0.RTC_SYNCBUSY,RTC_MODE0_SYNCBUSY_COUNT(1),false,31);
    RTC_REGS->MODE0.RTC_COMP[0]=ticks-1u;
    wait32(&RTC_REGS->MODE0.RTC_SYNCBUSY,RTC_MODE0_SYNCBUSY_COMP0(1),false,32);
    RTC_REGS->MODE0.RTC_INTFLAG=RTC_MODE0_INTFLAG_CMP0(1)|RTC_MODE0_INTFLAG_OVF(1);
    RTC_REGS->MODE0.RTC_CTRLA |= RTC_MODE0_CTRLA_ENABLE(1);
    wait32(&RTC_REGS->MODE0.RTC_SYNCBUSY,RTC_MODE0_SYNCBUSY_ENABLE(1),false,33);
}

void rtc_init(bool interrupt,bool event)
{
    MCLK_REGS->MCLK_APBAMASK |= MCLK_APBAMASK_RTC(1)|MCLK_APBAMASK_OSC32KCTRL(1);
    RTC_REGS->MODE0.RTC_CTRLA &= ~RTC_MODE0_CTRLA_ENABLE(1);
    wait32(&RTC_REGS->MODE0.RTC_SYNCBUSY,RTC_MODE0_SYNCBUSY_ENABLE(1),false,34);
    RTC_REGS->MODE0.RTC_CTRLA=RTC_MODE0_CTRLA_SWRST(1);
    wait32(&RTC_REGS->MODE0.RTC_SYNCBUSY,RTC_MODE0_SYNCBUSY_SWRST(1),false,35);
    wait16(&RTC_REGS->MODE0.RTC_CTRLA,RTC_MODE0_CTRLA_SWRST(1),false,35);
    OSC32KCTRL_REGS->OSC32KCTRL_OSCULP32K |= OSC32KCTRL_OSCULP32K_EN32K(1);
    OSC32KCTRL_REGS->OSC32KCTRL_RTCCTRL=OSC32KCTRL_RTCCTRL_RTCSEL_ULP32K;
    RTC_REGS->MODE0.RTC_CTRLA=RTC_MODE0_CTRLA_MODE_COUNT32|RTC_MODE0_CTRLA_MATCHCLR(1)|RTC_MODE0_CTRLA_PRESCALER_DIV1;
    if (event) RTC_REGS->MODE0.RTC_EVCTRL=RTC_MODE0_EVCTRL_CMPEO0(1);
    if (interrupt) {
        RTC_REGS->MODE0.RTC_INTENSET=RTC_MODE0_INTENSET_CMP0(1);
        NVIC_ClearPendingIRQ(RTC_IRQn); NVIC_SetPriority(RTC_IRQn,3); NVIC_EnableIRQ(RTC_IRQn);
    }
    rtc_set_period(32768);
}

void pwm_init(void)
{
    MCLK_REGS->MCLK_APBBMASK |= MCLK_APBBMASK_TCC0(1);
    clock_channel(TCC0_GCLK_ID,0);
    TCC0_REGS->TCC_CTRLA=0;
    wait32(&TCC0_REGS->TCC_SYNCBUSY,TCC_SYNCBUSY_ENABLE(1),false,40);
    TCC0_REGS->TCC_CTRLA=TCC_CTRLA_SWRST(1);
    wait32(&TCC0_REGS->TCC_SYNCBUSY,TCC_SYNCBUSY_SWRST(1),false,41);
    wait32(&TCC0_REGS->TCC_CTRLA,TCC_CTRLA_SWRST(1),false,41);
    /* Original 48 MHz/256 = 187.5 kHz retained; D2 has no onboard LED. */
    TCC0_REGS->TCC_WAVE=TCC_WAVE_WAVEGEN_NPWM;
    wait32(&TCC0_REGS->TCC_SYNCBUSY,TCC_SYNCBUSY_WAVE(1),false,42);
    TCC0_REGS->TCC_PER=255;
    wait32(&TCC0_REGS->TCC_SYNCBUSY,TCC_SYNCBUSY_PER(1),false,43);
    TCC0_REGS->TCC_CC[2]=128;
    wait32(&TCC0_REGS->TCC_SYNCBUSY,TCC_SYNCBUSY_CC2(1),false,44);
    pin_mux(2,18,5); /* D2=PC18/F=TCC0/WO2, same MCU pad as manual's LED. */
    PORT_REGS->GROUP[2].PORT_DIRSET=1u<<18;
    TCC0_REGS->TCC_CTRLA=TCC_CTRLA_ENABLE(1);
    wait32(&TCC0_REGS->TCC_SYNCBUSY,TCC_SYNCBUSY_ENABLE(1),false,45);
}

void adc_init(bool event_driven,bool twelve_bit)
{
    MCLK_REGS->MCLK_APBDMASK |= MCLK_APBDMASK_ADC1(1);
    clock_channel(ADC1_GCLK_ID,0);
    ADC1_REGS->ADC_CTRLA=0;
    wait32(&ADC1_REGS->ADC_SYNCBUSY,ADC_SYNCBUSY_ENABLE(1),false,50);
    ADC1_REGS->ADC_CTRLA=ADC_CTRLA_SWRST(1);
    wait32(&ADC1_REGS->ADC_SYNCBUSY,ADC_SYNCBUSY_SWRST(1),false,51);
    wait16(&ADC1_REGS->ADC_CTRLA,ADC_CTRLA_SWRST(1),false,51);
    PORT_REGS->GROUP[1].PORT_DIRCLR=1u<<4;
    pin_mux(1,4,1); /* A7=PB04/B=ADC1 AIN6; digital buffer/pull disabled. */
    uint32_t cal=SW0_FUSES_REGS->FUSES_SW0_WORD_0;
    ADC1_REGS->ADC_CALIB=
        ADC_CALIB_BIASCOMP((cal & FUSES_SW0_WORD_0_ADC1_BIASCOMP_Msk)>>FUSES_SW0_WORD_0_ADC1_BIASCOMP_Pos)
        |ADC_CALIB_BIASREFBUF((cal & FUSES_SW0_WORD_0_ADC1_BIASREFBUF_Msk)>>FUSES_SW0_WORD_0_ADC1_BIASREFBUF_Pos)
        |ADC_CALIB_BIASR2R((cal & FUSES_SW0_WORD_0_ADC1_BIASR2R_Msk)>>FUSES_SW0_WORD_0_ADC1_BIASR2R_Pos);
    SUPC_REGS->SUPC_VREF=SUPC_VREF_SEL_2V5|SUPC_VREF_ONDEMAND(1);
    ADC1_REGS->ADC_REFCTRL=ADC_REFCTRL_REFSEL_INTREF;
    wait32(&ADC1_REGS->ADC_SYNCBUSY,ADC_SYNCBUSY_REFCTRL(1),false,52);
    ADC1_REGS->ADC_INPUTCTRL=ADC_INPUTCTRL_MUXNEG_GND|ADC_INPUTCTRL_MUXPOS_AIN6;
    wait32(&ADC1_REGS->ADC_SYNCBUSY,ADC_SYNCBUSY_INPUTCTRL(1),false,53);
    ADC1_REGS->ADC_CTRLB=(twelve_bit?ADC_CTRLB_RESSEL_12BIT:ADC_CTRLB_RESSEL_8BIT)
        |(event_driven?0:ADC_CTRLB_FREERUN(1));
    wait32(&ADC1_REGS->ADC_SYNCBUSY,ADC_SYNCBUSY_CTRLB(1),false,54);
    ADC1_REGS->ADC_SAMPCTRL=ADC_SAMPCTRL_SAMPLEN(15);
    wait32(&ADC1_REGS->ADC_SYNCBUSY,ADC_SYNCBUSY_SAMPCTRL(1),false,55);
    ADC1_REGS->ADC_AVGCTRL=twelve_bit?(ADC_AVGCTRL_SAMPLENUM_8|ADC_AVGCTRL_ADJRES(3)):0;
    if (event_driven) ADC1_REGS->ADC_EVCTRL=ADC_EVCTRL_STARTEI(1);
    ADC1_REGS->ADC_CTRLA=ADC_CTRLA_PRESCALER_DIV256|ADC_CTRLA_ENABLE(1);
    wait32(&ADC1_REGS->ADC_SYNCBUSY,ADC_SYNCBUSY_ENABLE(1),false,56);
}

void dma_init(bool to_memory,bool event_output)
{
    MCLK_REGS->MCLK_AHBMASK |= MCLK_AHBMASK_DMAC(1);
    DMAC_REGS->DMAC_CTRL=0;
    DMAC_REGS->DMAC_CRCCTRL=0;
    DMAC_REGS->DMAC_CTRL=DMAC_CTRL_SWRST(1);
    wait16(&DMAC_REGS->DMAC_CTRL,DMAC_CTRL_SWRST(1),false,57);
    g_descriptor.DMAC_BTCTRL=0; /* VALID must be written last. */
    g_descriptor.DMAC_BTCNT=SAMPLE_COUNT;
    g_descriptor.DMAC_SRCADDR=(uint32_t)&ADC1_REGS->ADC_RESULT;
    g_descriptor.DMAC_DSTADDR=to_memory?(uint32_t)(g_samples+SAMPLE_COUNT):(uint32_t)&TCC0_REGS->TCC_CCBUF[2];
    g_descriptor.DMAC_DESCADDR=to_memory?0:(uint32_t)&g_descriptor;
    g_descriptor.DMAC_BTCTRL=DMAC_BTCTRL_VALID(1)
        |(to_memory?(DMAC_BTCTRL_BEATSIZE_HWORD|DMAC_BTCTRL_DSTINC(1)|DMAC_BTCTRL_BLOCKACT_INT)
                   :(DMAC_BTCTRL_BEATSIZE_BYTE|DMAC_BTCTRL_BLOCKACT_SUSPEND))
        |(event_output?DMAC_BTCTRL_EVOSEL_BURST:0);
    DMAC_REGS->DMAC_BASEADDR=(uint32_t)&g_descriptor;
    DMAC_REGS->DMAC_WRBADDR=(uint32_t)&g_writeback;
    DMAC_REGS->CHANNEL[0].DMAC_CHCTRLA=DMAC_CHCTRLA_TRIGSRC(ADC1_DMAC_ID_RESRDY)
        |DMAC_CHCTRLA_TRIGACT_BURST|DMAC_CHCTRLA_BURSTLEN_SINGLE;
    DMAC_REGS->CHANNEL[0].DMAC_CHPRILVL=DMAC_CHPRILVL_PRILVL_LVL0;
    if (event_output) DMAC_REGS->CHANNEL[0].DMAC_CHEVCTRL=DMAC_CHEVCTRL_EVOE(1)|DMAC_CHEVCTRL_EVOMODE_DEFAULT;
    DMAC_REGS->CHANNEL[0].DMAC_CHINTFLAG=DMAC_CHINTFLAG_Msk;
    DMAC_REGS->CHANNEL[0].DMAC_CHINTENSET=DMAC_CHINTENSET_TERR(1)
        |(to_memory?DMAC_CHINTENSET_TCMPL(1):DMAC_CHINTENSET_SUSP(1));
    NVIC_ClearPendingIRQ(DMAC_0_IRQn); NVIC_SetPriority(DMAC_0_IRQn,1); NVIC_EnableIRQ(DMAC_0_IRQn);
    __DMB();
    DMAC_REGS->DMAC_CTRL=DMAC_CTRL_LVLEN0(1)|DMAC_CTRL_DMAENABLE(1);
    DMAC_REGS->CHANNEL[0].DMAC_CHCTRLA |= DMAC_CHCTRLA_ENABLE(1);
}

void events_init(void)
{
    MCLK_REGS->MCLK_APBBMASK |= MCLK_APBBMASK_EVSYS(1);
    EVSYS_REGS->EVSYS_CTRLA=EVSYS_CTRLA_SWRST(1);
    wait8(&EVSYS_REGS->EVSYS_CTRLA,EVSYS_CTRLA_SWRST(1),false,58);
    /* Asynchronous paths do not require the per-channel GCLKs. */
    EVSYS_REGS->CHANNEL[0].EVSYS_CHANNEL=EVSYS_CHANNEL_PATH_ASYNCHRONOUS|EVSYS_CHANNEL_EVGEN(EVENT_ID_GEN_DMAC_CH_0);
    EVSYS_REGS->EVSYS_USER[EVENT_ID_USER_ADC1_START]=EVSYS_USER_CHANNEL(1);
    EVSYS_REGS->CHANNEL[1].EVSYS_CHANNEL=EVSYS_CHANNEL_PATH_ASYNCHRONOUS|EVSYS_CHANNEL_EVGEN(EVENT_ID_GEN_RTC_CMP_0);
    EVSYS_REGS->EVSYS_USER[EVENT_ID_USER_PORT_EV_0]=EVSYS_USER_CHANNEL(2);
    PORT_REGS->GROUP[1].PORT_EVCTRL=PORT_EVCTRL_EVACT0_TGL|PORT_EVCTRL_PID0(1)|PORT_EVCTRL_PORTEI0(1);
}

void eic_init(void)
{
    MCLK_REGS->MCLK_APBAMASK |= MCLK_APBAMASK_EIC(1);
    GCLK_REGS->GCLK_GENCTRL[1]=GCLK_GENCTRL_SRC_DFLL|GCLK_GENCTRL_DIV(48000)|GCLK_GENCTRL_GENEN(1);
    wait32(&GCLK_REGS->GCLK_SYNCBUSY,GCLK_SYNCBUSY_GENCTRL_GCLK1,false,60);
    clock_channel(EIC_GCLK_ID,1);
    EIC_REGS->EIC_CTRLA=0;
    /* EIC SYNCBUSY is 32 bit in this device's DFP. */
    wait32(&EIC_REGS->EIC_SYNCBUSY,EIC_SYNCBUSY_ENABLE(1),false,61);
    EIC_REGS->EIC_CTRLA=EIC_CTRLA_SWRST(1);
    wait32(&EIC_REGS->EIC_SYNCBUSY,EIC_SYNCBUSY_SWRST(1),false,62);
    wait8(&EIC_REGS->EIC_CTRLA,EIC_CTRLA_SWRST(1),false,62);
    pin_mux(2,4,0);
    PORT_REGS->GROUP[2].PORT_PINCFG[4] |= PORT_PINCFG_INEN(1)|PORT_PINCFG_PULLEN(1);
    EIC_REGS->EIC_CONFIG[0]=EIC_CONFIG_SENSE4_FALL;
    EIC_REGS->EIC_ASYNCH=0; /* Synchronous stability debounce, not immediate first edge. */
    EIC_REGS->EIC_DEBOUNCEN=EIC_DEBOUNCEN_DEBOUNCEN(1u<<4);
    /* DIV8 (encoding 2), 8 stable ticks at nominal 1 kHz -> about 64 ms. */
    EIC_REGS->EIC_DPRESCALER=EIC_DPRESCALER_TICKON(1)|EIC_DPRESCALER_STATES0(1)|EIC_DPRESCALER_PRESCALER0_DIV8;
    EIC_REGS->EIC_INTFLAG=EIC_INTFLAG_EXTINT(1u<<4);
    EIC_REGS->EIC_INTENSET=EIC_INTENSET_EXTINT(1u<<4);
    NVIC_ClearPendingIRQ(EIC_EXTINT_4_IRQn); NVIC_SetPriority(EIC_EXTINT_4_IRQn,3); NVIC_EnableIRQ(EIC_EXTINT_4_IRQn);
    EIC_REGS->EIC_CTRLA=EIC_CTRLA_ENABLE(1);
    wait32(&EIC_REGS->EIC_SYNCBUSY,EIC_SYNCBUSY_ENABLE(1),false,63);
}

void adc_check_overrun(void)
{
    if (ADC1_REGS->ADC_INTFLAG & ADC_INTFLAG_OVERRUN(1)) {
        ++g_adc_overruns;
        ADC1_REGS->ADC_INTFLAG=ADC_INTFLAG_OVERRUN(1);
    }
}
